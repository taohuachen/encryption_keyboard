# IAR project encryption keyboard.ewp, settings and files
configuration encryption keyboard (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103VE ST STM32F103VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE
  ICCARM.CCIncludePath2: C:\Users\Administrator\Desktop\encryption_keyboard\.git; C:\Users\Administrator\Desktop\encryption_keyboard\Core; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers; C:\Users\Administrator\Desktop\encryption_keyboard\EWARM; C:\Users\Administrator\Desktop\encryption_keyboard\Middlewares; C:\Users\Administrator\Desktop\encryption_keyboard\User; C:\Users\Administrator\Desktop\encryption_keyboard\.git\hooks; C:\Users\Administrator\Desktop\encryption_keyboard\.git\info; C:\Users\Administrator\Desktop\encryption_keyboard\.git\logs; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects; C:\Users\Administrator\Desktop\encryption_keyboard\.git\refs; C:\Users\Administrator\Desktop\encryption_keyboard\.git\logs\refs; C:\Users\Administrator\Desktop\encryption_keyboard\.git\logs\refs\heads; C:\Users\Administrator\Desktop\encryption_keyboard\.git\logs\refs\remotes; C:\Users\Administrator\Desktop\encryption_keyboard\.git\logs\refs\remotes\origin; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\03; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\04; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\05; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\09; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\0b; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\0c; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\0d; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\12; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\13; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\16; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\17; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\18; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\1b; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\1c; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\20; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\22; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\26; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\29; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\2a; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\2c; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\2d; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\30; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\31; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\32; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\33; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\35; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\39; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\3b; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\3e; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\41; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\42; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\49; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\4d; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\4e; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\4f; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\51; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\56; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\59; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\5c; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\5d; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\5e; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\60; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\64; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\65; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\66; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\68; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\6c; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\6e; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\6f; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\71; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\72; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\73; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\74; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\78; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\79; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\7a; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\7c; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\80; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\87; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\88; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\8b; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\8d; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\8f; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\91; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\97; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\98; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\99; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\9a; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\9e; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\a0; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\a3; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\a6; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\a7; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\a9; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\ac; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\ad; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\ae; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\af; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\b0; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\b3; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\b4; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\b5; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\b8; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\b9; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\bb; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\bc; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\bf; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\c5; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\c7; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\cd; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\ce; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\d0; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\d2; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\d3; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\d4; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\d5; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\d6; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\d7; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\db; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\dc; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\e0; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\e1; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\e2; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\e4; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\e5; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\e7; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\e9; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\ea; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\ed; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\ef; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\f3; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\f4; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\f6; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\f8; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\f9; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\info; C:\Users\Administrator\Desktop\encryption_keyboard\.git\objects\pack; C:\Users\Administrator\Desktop\encryption_keyboard\.git\refs\heads; C:\Users\Administrator\Desktop\encryption_keyboard\.git\refs\remotes; C:\Users\Administrator\Desktop\encryption_keyboard\.git\refs\tags; C:\Users\Administrator\Desktop\encryption_keyboard\.git\refs\remotes\origin; C:\Users\Administrator\Desktop\encryption_keyboard\Core\Inc; C:\Users\Administrator\Desktop\encryption_keyboard\Core\Src; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\CMSIS; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\STM32F1xx_HAL_Driver; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\CMSIS\Device; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\CMSIS\Include; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\CMSIS\Device\ST; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\CMSIS\Device\ST\STM32F1xx; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\CMSIS\Device\ST\STM32F1xx\Include; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\CMSIS\Device\ST\STM32F1xx\Source; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\CMSIS\Device\ST\STM32F1xx\Source\Templates; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\STM32F1xx_HAL_Driver\Inc; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\STM32F1xx_HAL_Driver\Src; C:\Users\Administrator\Desktop\encryption_keyboard\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy; C:\Users\Administrator\Desktop\encryption_keyboard\EWARM\encryption keyboard; C:\Users\Administrator\Desktop\encryption_keyboard\EWARM\settings; C:\Users\Administrator\Desktop\encryption_keyboard\EWARM\encryption keyboard\Exe; C:\Users\Administrator\Desktop\encryption_keyboard\EWARM\encryption keyboard\List; C:\Users\Administrator\Desktop\encryption_keyboard\EWARM\encryption keyboard\Obj; C:\Users\Administrator\Desktop\encryption_keyboard\Middlewares\Third_Party; C:\Users\Administrator\Desktop\encryption_keyboard\Middlewares\Third_Party\FreeRTOS; C:\Users\Administrator\Desktop\encryption_keyboard\Middlewares\Third_Party\FreeRTOS\Source; C:\Users\Administrator\Desktop\encryption_keyboard\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; C:\Users\Administrator\Desktop\encryption_keyboard\Middlewares\Third_Party\FreeRTOS\Source\include; C:\Users\Administrator\Desktop\encryption_keyboard\Middlewares\Third_Party\FreeRTOS\Source\portable; C:\Users\Administrator\Desktop\encryption_keyboard\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR; C:\Users\Administrator\Desktop\encryption_keyboard\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang; C:\Users\Administrator\Desktop\encryption_keyboard\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3; C:\Users\Administrator\Desktop\encryption_keyboard\User\applications; C:\Users\Administrator\Desktop\encryption_keyboard\User\bsp; C:\Users\Administrator\Desktop\encryption_keyboard\User\components; C:\Users\Administrator\Desktop\encryption_keyboard\User\bsp\buffer; C:\Users\Administrator\Desktop\encryption_keyboard\User\bsp\buzzer; C:\Users\Administrator\Desktop\encryption_keyboard\User\bsp\common; C:\Users\Administrator\Desktop\encryption_keyboard\User\bsp\delay; C:\Users\Administrator\Desktop\encryption_keyboard\User\bsp\io; C:\Users\Administrator\Desktop\encryption_keyboard\User\bsp\keyboard; C:\Users\Administrator\Desktop\encryption_keyboard\User\bsp\led; C:\Users\Administrator\Desktop\encryption_keyboard\User\bsp\spi; C:\Users\Administrator\Desktop\encryption_keyboard\User\bsp\switch
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: encryption keyboard.hex
  ILINK.IlinkOutputFile: encryption keyboard.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Core/Src/: freertos.c gpio.c main.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group User/applications
    ../User/applications/: app_buzzer.c app_keyboard.c app_start.c
  group User/bsp
    ../User/bsp/buzzer/: buzzer.c
    ../User/bsp/delay/: delay.c
    ../User/bsp/io/: io.c
    ../User/bsp/keyboard/: keyboard.c
    ../User/bsp/led/: led.c
    ../User/bsp/switch/: switch.c
